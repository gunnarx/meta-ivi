PR = "r1"

EXTRA_OECONF_append = " --without-gssapi"
